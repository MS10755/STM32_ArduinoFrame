# Keil uVision project Template.uvprojx, settings and files
target Target 1 (6150000::V6.15::.\ARMCompiler6.15)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=9 wLevel=1
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,ARDUINO_STM32
  c include: ..\Frame\LLA_Drivers;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\Drivers\CMSIS\CM3\CoreSupport;..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Frame;..\USER;..\Drivers\STM32F10x_StdPeriph_Driver;..\Drivers;..\Frame\ArduinoAPI;..\Libraries\Ethernet\src;..\Libraries\Adafruit_MQTT_Library;..\Libraries\ArduinoJson;..\Libraries\ArduinoJson\src;..\Libraries\Adafruit_BusIO;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ILI9481FMC16_Library;..\Libraries\Adafruit_ST7735-Library;..\Libraries\Adafruit_SSD1309_Library;..\Libraries\MillisTaskManager;..\Libraries\SdFat\src;..\Libraries\SdFat\src\SdCard;..\Drivers\USB\STM32_USB-FS-Device_Driver\inc;..\Drivers\USB\APP\Virtual_COM_Port\inc;..\Drivers\USB\APP\Mass_Storage\inc;..\Libraries\Adafruit_VS1053_Library;..\FreeRTOSv9.0.0\inc;..\FreeRTOSv9.0.0\port;..\FreeRTOSv9.0.0\port\GCC\ARM_CM3;..\Libraries\Arduino-Websocket-Fast\src;..\Libraries\EEPROM\src;..\Libraries\w25qxx\src;..\Libraries\w25qxx\interface;..\Libraries\littlefs;..\Libraries\w25qxx;..\Libraries\littlefs\device
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../Drivers/: retarget_io.c armv6O0fix.c
  group LLA_Drivers
    ../Frame/LLA_Drivers/src/: LLA_ADC.c LLA_advanceIO.c LLA_baseIO.c LLA_errorCode.c LLA_EXTI.c LLA_flash.c LLA_PWM.c LLA_SPI.c LLA_SYS_clock.c LLA_SYS_IRQ.c LLA_SYS_time.c LLA_SYS_rest.c LLA_Template.c LLA_timer.c LLA_UART.c LLA_USB.c LLA_WDG.c LLA_IOMaps.c
  group ArduinoAPI
    ../Frame/ArduinoAPI/: dtostrf.c hooks.c itoa.c WInterrupts.c wiring.c wiring_analog.c wiring_digital.c wiring_pulse.c wiring_shift.c HardwareSerial.cpp IPAddress.cpp new.cpp Print.cpp SPI.cpp Stream.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group USER
    ../Frame/: Frame.cpp
    ../USER/: main.cpp debug_wrapper.cpp stdio.c
  group Ethernet
    ../Libraries/Ethernet/src/utility/: w5100.cpp
    ../Libraries/Ethernet/src/: Dhcp.cpp Dns.cpp Ethernet.cpp EthernetClient.cpp EthernetServer.cpp EthernetUdp.cpp socket.cpp
  group Adafruit_FONA_Library
    ../Libraries/Adafruit_FONA_Library/: Adafruit_FONA.cpp
  group Adafruit_MQTT_Library
    ../Libraries/Adafruit_MQTT_Library/: Adafruit_MQTT.cpp Adafruit_MQTT_Client.cpp
  group Adafruit_SleepyDog_Library
    ../Libraries/Adafruit_SleepyDog_Library/utility/: WatchdogSTM32F10x.cpp
    ../Libraries/Adafruit_SleepyDog_Library/: Adafruit_SleepyDog.cpp
  group Adafruit_BusIO
    ../Libraries/Adafruit_BusIO/: Adafruit_BusIO_Register.cpp Adafruit_I2CDevice.cpp Adafruit_SPIDevice.cpp
  group Adafruit_ILI9481FMC16_Library
    ../Libraries/Adafruit_ILI9481FMC16_Library/: Adafruit_ILI9481FMC16.cpp fmc16bit.c
  group Adafruit_GFX_Library
    ../Libraries/Adafruit_GFX_Library/: glcdfont.c Adafruit_GFX.cpp Adafruit_GrayOLED.cpp Adafruit_SPITFT.cpp
  group Adafruit_ST7735-Library
    ../Libraries/Adafruit_ST7735-Library/: Adafruit_ST77xx.cpp Adafruit_ST7735.cpp Adafruit_ST7789.cpp
  group MillisTaskManager
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
  group Adafruit_SSD1309_Library
    ../Libraries/Adafruit_SSD1309_Library/: oled.c spi1.c Adafruit_SSD1309.cpp
  group SdFat
    ../Libraries/SdFat/src/common/: FmtNumber.cpp FsCache.cpp FsDateTime.cpp FsName.cpp FsStructs.cpp FsUtf.cpp PrintBasic.cpp upcase.cpp
    ../Libraries/SdFat/src/ExFatLib/: ExFatDbg.cpp ExFatFile.cpp ExFatFilePrint.cpp ExFatFileWrite.cpp ExFatFormatter.cpp ExFatName.cpp ExFatPartition.cpp ExFatVolume.cpp
    ../Libraries/SdFat/src/FatLib/: FatDbg.cpp FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatFormatter.cpp FatName.cpp FatPartition.cpp FatVolume.cpp
    ../Libraries/SdFat/src/FsLib/: FsFile.cpp FsNew.cpp FsVolume.cpp
    ../Libraries/SdFat/src/iostream/: istream.cpp ostream.cpp StdioStream.cpp StreamBaseClass.cpp
    ../Libraries/SdFat/src/SdCard/: SdCardInfo.cpp SdioTeensy.cpp SdSpiCard.cpp SdioSTM32F103.cpp sdio_sdcard.c
    ../Libraries/SdFat/src/SpiDriver/: SdSpiArtemis.cpp SdSpiChipSelect.cpp SdSpiDue.cpp SdSpiESP.cpp SdSpiParticle.cpp SdSpiSTM32.cpp SdSpiSTM32Core.cpp SdSpiTeensy3.cpp
    ../Libraries/SdFat/src/: FreeStack.cpp MinimumSerial.cpp
  group STM32_USB-FS-Device_Driver
    ../Drivers/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Mass_Storage
    ../Drivers/USB/APP/Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group Adafruit_VS1053_Library
    ../Libraries/Adafruit_VS1053_Library/: Adafruit_VS1053.cpp
  group FreeRTOS
    ../FreeRTOSv9.0.0/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOSv9.0.0/port/MemMang/: heap_4.c
    ../FreeRTOSv9.0.0/port/GCC/ARM_CM3/: port.c
    ../FreeRTOSv9.0.0/port/: FreeRTOSConfig.h
  group Arduino-Websocket-Fast
    ../Libraries/Arduino-Websocket-Fast/src/: Base64.cpp sha1.cpp WebSocketClient.cpp
  group EEPROM
    ../Libraries/EEPROM/src/utility/: flash_cache.cpp
  group w25qxx
    ../Libraries/w25qxx/src/: driver_w25qxx.c
    ../Libraries/w25qxx/interface/: driver_w25qxx_interface.c
    ../Libraries/w25qxx/: w25q128_user.c
  group littlefs
    ../Libraries/littlefs/: lfs.c lfs_util.c
    ../Libraries/littlefs/device/: dev_w25q128flash.c
