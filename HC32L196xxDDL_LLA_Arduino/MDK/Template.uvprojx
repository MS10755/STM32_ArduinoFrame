# Keil uVision project Template.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: HC32L196KCTA HDSC
  pack: HDSC.HC32L19X.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: ARDUINO=111,__AVR__,DEBUG,LLA_DRIVERS
  c include: ..\Drivers\inc;..\Frame;..\Drivers\common;..\Frame\ArduinoAPI;..\Libraries\Ethernet\src;..\Libraries\Ethernet\src\utility;..\Libraries\ArduinoRS485\src;..\Libraries\ArduinoModbus\src\libmodbus;..\Libraries\ArduinoModbus\src;..\Libraries\MemoryInfo;..\Libraries\Arduino_DebugUtils\src;..\USER;..\Libraries\Adafruit_BusIO;..\Libraries\Adafruit_FONA_Library\includes\platform;..\Libraries\Adafruit_FONA_Library\includes;..\Libraries\Adafruit_FONA_Library;..\Libraries\Adafruit_MQTT_Library;..\Libraries\Adafruit_SHT31_Library;..\Libraries\Adafruit_SleepyDog_Library\utility;..\Libraries\Adafruit_SleepyDog_Library;..\Libraries\cJSON;..\Libraries\NTPClient;..\Libraries\LiquidCrystal_I2C;..\Libraries\U8g2\src;..\Libraries\U8g2\src\clib;..\Libraries\ArduinoJson;..\Libraries\ArduinoJson\src\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../USER/: main.cpp debug_wrapper.cpp
    ../Frame/: Frame.cpp
  group LLA_Drivers
    ../Frame/LLA_Drivers/src/: LLA_ADC.c LLA_advanceIO.c LLA_baseIO.c LLA_EXTI.c LLA_flash.c LLA_PWM.c LLA_SPI.c LLA_SYS_clock.c LLA_SYS_IRQ.c LLA_SYS_time.c LLA_timer.c LLA_UART.c LLA_USB.c LLA_WDG.c LLA_errorCode.c LLA_SYS_rest.c
  group Drivers
    ../Drivers/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
    ../Drivers/: armv6O0fix.c
  group ArduinoAPI
    ../Frame/ArduinoAPI/: dtostrf.c hooks.c itoa.c WInterrupts.c wiring.c wiring_analog.c wiring_digital.c wiring_pulse.c wiring_shift.c HardwareSerial.cpp IPAddress.cpp new.cpp Print.cpp SPI.cpp Stream.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Ethernet
    ../Libraries/Ethernet/src/utility/: w5100.cpp
    ../Libraries/Ethernet/src/: Dhcp.cpp Dns.cpp Ethernet.cpp EthernetClient.cpp EthernetServer.cpp EthernetUdp.cpp socket.cpp
  group ArduinoRS485
    ../Libraries/ArduinoRS485/src/: RS485.cpp
  group ArduinoModbus
    ../Libraries/ArduinoModbus/src/libmodbus/: modbus.c modbus-data.c modbus-rtu.cpp modbus-tcp.cpp
    ../Libraries/ArduinoModbus/src/: ModbusClient.cpp ModbusRTUClient.cpp ModbusRTUServer.cpp ModbusServer.cpp ModbusTCPClient.cpp ModbusTCPServer.cpp
  group MemoryInfo
    ../Libraries/MemoryInfo/: StackInfo.c MemoryInfo.cpp
  group Arduino_DebugUtils
    ../Libraries/Arduino_DebugUtils/src/: Arduino_DebugUtils.cpp
  group Adafruit_BusIO
    ../Libraries/Adafruit_BusIO/: Adafruit_BusIO_Register.cpp Adafruit_I2CDevice.cpp Adafruit_SPIDevice.cpp
  group Adafruit_FONA_Library
    ../Libraries/Adafruit_FONA_Library/: Adafruit_FONA.cpp
  group Adafruit_MQTT_Library
    ../Libraries/Adafruit_MQTT_Library/: Adafruit_MQTT.cpp Adafruit_MQTT_Client.cpp
  group Adafruit_SHT31_Library
    ../Libraries/Adafruit_SHT31_Library/: Adafruit_SHT31.cpp
  group Adafruit_SleepyDog_Library
    ../Libraries/Adafruit_SleepyDog_Library/utility/: WatchdogLLA.cpp
    ../Libraries/Adafruit_SleepyDog_Library/: Adafruit_SleepyDog.cpp
  group cJSON
    ../Libraries/cJSON/: cJSON.c cJSON_Utils.c
  group crc16
    ../Libraries/crc16/: CRC16.c
  group NTPClient
    ../Libraries/NTPClient/: NTPClient.cpp
  group LiquidCrystal_I2C
    ../Libraries/LiquidCrystal_I2C/: LiquidCrystal_I2C.cpp
  group U8g2
    ../Libraries/U8g2/src/clib/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_hd44102.c u8x8_d_il3820_296x128.c u8x8_d_ist3020.c u8x8_d_ist7920.c u8x8_d_ks0108.c u8x8_d_lc7981.c u8x8_d_ld7032_60x32.c u8x8_d_ls013b7dh03.c u8x8_d_max7219.c u8x8_d_pcd8544_84x48.c u8x8_d_pcf8812.c u8x8_d_pcf8814_hx1230.c u8x8_d_s1d15e06.c u8x8_d_s1d15721.c u8x8_d_sbn1661.c u8x8_d_sed1330.c u8x8_d_sh1106_64x32.c u8x8_d_sh1106_72x40.c u8x8_d_sh1107.c u8x8_d_sh1108.c u8x8_d_sh1122.c u8x8_d_ssd1305.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_72x40.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_2040x16.c u8x8_d_ssd1309.c u8x8_d_ssd1316.c u8x8_d_ssd1317.c u8x8_d_ssd1318.c u8x8_d_ssd1320.c u8x8_d_ssd1322.c u8x8_d_ssd1325.c u8x8_d_ssd1326.c u8x8_d_ssd1327.c u8x8_d_ssd1329.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8x8_d_st7511.c u8x8_d_st7528.c u8x8_d_st7565.c u8x8_d_st7567.c u8x8_d_st7571.c u8x8_d_st7586s_erc240160.c u8x8_d_st7586s_s028hn118a.c u8x8_d_st7586s_ymc240160.c u8x8_d_st7588.c u8x8_d_st7920.c u8x8_d_st75256.c u8x8_d_st75320.c u8x8_d_t6963.c u8x8_d_uc1601.c u8x8_d_uc1604.c u8x8_d_uc1608.c u8x8_d_uc1609.c u8x8_d_uc1610.c u8x8_d_uc1611.c u8x8_d_uc1617.c u8x8_d_uc1638.c u8x8_d_uc1701_dogs102.c u8x8_d_uc1701_mini12864.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
    ../Libraries/U8g2/src/: U8g2lib.cpp U8x8lib.cpp
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
